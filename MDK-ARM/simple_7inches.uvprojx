# Keil uVision project simple_7inches.uvprojx, settings and files
target simple_7inches (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: simple_7inches +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F429_439xx,USE_USB_OTG_FS,APPLICACION,USE_STDPERIPH_DRIVER,SYSTEM1,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Core\User\app\common\inc;..\Core\User\app\system\inc;..\Core\User\boot\Inc;..\Core\User\doc;..\Core\User\lib;..\Core\User\lib\bspLib\inc;..\Core\User\lib\bspLib\usb\FATFS\inc;..\Core\User\lib\bspLib\usb\STM32_USB_OTG_Driver\inc;..\Core\User\lib\bspLib\usb\STM32_USB_HOST_Library\Class\MSC\inc;..\Core\User\lib\bspLib\usb\STM32_USB_HOST_Library\Core\inc;..\Core\User\lib\bspLib\usb\USB_APP;..\Core\User\lib\doPTLib\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000080 size 0x2ff80
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/lib
    ../Core/User/lib/: cpulib.lib doptlib.lib
  group Application/fun
    ../Core/User/app/common/src/: communication.c exfunction.c flashsave.c function.c lcddisp.c Mit_funtion.c Mit_menu_files.c Patfun.c register.c ScrollBar.c Toast.c upflash.c msgpic.c
    ../Core/User/app/common/inc/: color.h integer.h menu.h register.h title.h
  group Application/sys
    ../Core/User/boot/Src/: main.c systemMain.c utility.c
  group Drivers/CMSIS
    ../Core/User/boot/Src/: system_stm32f4xx.c
  group Application/doc
    ../Core/User/doc/: readme.txt
  group Application/app
    ../Core/User/app/system/src/: menu_convert.c menu_create.c menu_documents.c menu_function.c menu_help.c menu_iotest.c menu_modify.c menu_p.c menu_program.c viewPattern.c
software components: CMSIS:CORE 4.3.0
